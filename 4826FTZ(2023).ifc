Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-01-30T15:11:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 30 15:11:57 2024 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\f24a711b-3b8c-41de-896d-9c90fd1cefdb\98ee0874-15ec-494d-9786-3457b75c8abb\ifc * Database version: 5507 * Database creation date: Tue Jan 30 15:11:56 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 30 15:11:56 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 30 15:11:56 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 4826FTZ Oras Stela, 4826FTZ(2023):4826FTZ Oras Stela:363700
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 153.414 mm; FaucetNominalHeight: 136 mm; FaucetNominalWidth: 66.5791 mm; HandShowerNominalDepth: 66.9785 mm; HandShowerNominalHeight: 309.751 mm; HandShowerNominalWidth: 56.8083 mm; InletConnectionSize: 8 mm
Type - Electrical - Bluetooth: 5.x (D060576); Electrical Connection: 230 / 9 V; Operating Voltage: 9 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 4826FTZ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150103384; EMC Directive: 2014/53/EU , 2011/65/EU; EN Standard: EN 15091; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110482; Noise Class: I (ISO 3822); NRF Number: 4200265; RSK Number: 8430081; Sales Package dimensions (LxWxH): 568 x 182 x 78; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/4826FTZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/4826FTZ; URL WEEE: http://static.oras.com/WEEE/4826FTZ
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/4826FTZ; 3D View: https://static.oras.com/AR/4826FTZ; Catalog Drawing URL: http://static.oras.com/catdrw/4826FTZ; Dimension Drawing URL: http://static.oras.com/dimdrw/4826FTZ; FDV Document URL: http://www.oras.com/datasheet/4826FTZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4826FTZ; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/4826FTZ; Interactive AR View URL: https://static.oras.com/AR/4826FTZ; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/4826FTZ; Model: 4826FTZ Oras Stela; Name_en: 4826FTZ Oras Stela; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 4826FTZ; Product Family: Safety Touchless;Bidetta;Plug transformer;Bluetooth®; Product Image URL: http://static.oras.com/image/4826FTZ; Product URL: http://static.oras.com/4826FTZ; Spare-Part Information URL: http://static.oras.com/sp/4826FTZ; Technical DataSheet URL: http://www.oras.com/datasheet/4826FTZ/en; Type Name: 4826FTZ Oras Stela; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting;Software settings adjustable via App; Aerator: Hidden aerator;Adjustable flow angle; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: EB; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: ;Power supply; Flow Rate At 300kPa With Flow Controller: 0.00282517 m3/s; Hand Shower: Remote-operated Smart Bidetta; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Mixing valve for manual temperature control; Mounting Holes: 1 hole; Operating Distance: 20-130 mm (110/130/160 mm); Pressure Loss With Flow 01ls: 435000 Pa; Shower Parts: Hand shower;Shower holder;Shower hose (1750 mm); Spout Projection: 105 mm; Spout Type: Fixed spout;Casted construction; Surface treatment: Chrome; Temperature: Temperature limiter; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4826FTZ(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 4826FTZ; Name: 4826FTZ Oras Stela; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x155x140 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 4826FTZ Oras Stela; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 4826FTZ; Manufacturer: Oras
Pset_ProductRequirements - Name: 4826FTZ Oras Stela; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0831358 m2; Volume: 0.00257073 m3
Identity Data - Mark: 5
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 4826FTZ(2023): 4826FTZ Oras Stela; Family and Type: 4826FTZ(2023): 4826FTZ Oras Stela; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4826FTZ(2023): 4826FTZ Oras Stela; Type Id: 4826FTZ(2023): 4826FTZ Oras Stela; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
